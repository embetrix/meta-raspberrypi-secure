# Enable xxd-native
BBCLASSEXTEND = "native"
