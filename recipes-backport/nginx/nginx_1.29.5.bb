require nginx.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=79da1c70d587d3a199af9255ad393f99"

SRC_URI[sha256sum] = "6744768a4114880f37b13a0443244e731bcb3130c0a065d7e37d8fd589ade374"

