DESCRIPTION = "rpi secure base image swupdate compound image"

require rpi-secure-image-update.inc
