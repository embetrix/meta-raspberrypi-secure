DESCRIPTION = "rpi secure demo image swupdate compound image"

require rpi-secure-image-update.inc
