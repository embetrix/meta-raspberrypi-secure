# remove heavy python3-tpm2-pytss dependency
RDEPENDS:packagegroup-security-tpm2:remove = "python3-tpm2-pytss"
